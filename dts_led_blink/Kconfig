## dts_led_blink/Kconfig
```kconfig
source "Kconfig.zephyr"

config DELAY
    int "Application delay in milliseconds"
    default 1000
```
